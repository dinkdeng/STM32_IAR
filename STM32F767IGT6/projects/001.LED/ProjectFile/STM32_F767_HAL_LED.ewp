# IAR project STM32_F767_HAL_LED.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F767IG ST STM32F767IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\common\chipSupport; ..\..\..\common\Func\CoreFunc; ..\..\..\common\Func\DeviceFunc; ..\..\..\common\Func\DinkFunc; ..\..\..\common\Func\MspFunc; ..\..\..\common\Func\CallBackFunc; ..\..\..\common\Func\SupportFunc; ..\..\..\common\lib\inc; ..\UserFile
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_F767_HAL_LED.hex
  ILINK.IlinkOutputFile: STM32_F767_HAL_LED.out
  ILINK.IlinkIcfFile: ..\..\..\common\startup\linker\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common/chipSupport
    ../../../common/chipSupport/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f767xx.h stm32f7xx.h system_stm32f7xx.h
  group common/Func/CoreFunc
    ../../../common/Func/CoreFunc/: CoreTimerDelay.c CoreTimerDelay.h
  group common/Func/DeviceFunc
    ../../../common/Func/DeviceFunc/: DeviceLed.c DeviceLed.h
  group common/Func/MspFunc
    ../../../common/Func/MspFunc/: MspHal.c MspTick.c
  group common/Func/SupportFunc
    ../../../common/Func/SupportFunc/: stm32f7xx_hal_conf.h stm32f7xx_it.c stm32f7xx_it.h system_stm32f7xx.c
  group common/lib/inc
    ../../../common/lib/inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_mmc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_smbus.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_adc.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_crc.h stm32f7xx_ll_dac.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_exti.h stm32f7xx_ll_fmc.h stm32f7xx_ll_gpio.h stm32f7xx_ll_i2c.h stm32f7xx_ll_iwdg.h stm32f7xx_ll_lptim.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_rng.h stm32f7xx_ll_rtc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_spi.h stm32f7xx_ll_system.h stm32f7xx_ll_tim.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h stm32f7xx_ll_wwdg.h
  group common/lib/src
    ../../../common/lib/src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c
  group common/startup
    ../../../common/startup/: startup_stm32f767xx.s
  group common/startup/linker
    ../../../common/startup/linker/: stm32f767xx_flash.icf
  group UserFile
    ../UserFile/: LedMain.c
