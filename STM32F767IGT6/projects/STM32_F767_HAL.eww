<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\001.LED\ProjectFile\STM32_F767_HAL_LED.ewp</path>
    </project>
    <batchBuild />
</workspace>
