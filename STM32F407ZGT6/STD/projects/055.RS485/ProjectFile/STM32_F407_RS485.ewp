# IAR project STM32_F407_RS485.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\common\startup; ..\..\..\common\chipSupport; ..\..\..\common\lib\inc; ..\..\..\common\Func\CoreFunc; ..\..\..\common\Func\DeviceFunc; ..\..\..\common\Func\DinkFunc; ..\..\..\common\Func\SupportFunc; ..\UserFile
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_F407_RS485.hex
  ILINK.IlinkOutputFile: STM32_F407_STD_RS485.out
  ILINK.IlinkIcfFile: ..\..\..\common\startup\linker\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common/chipSupport
    ../../../common/chipSupport/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f4xx.h
  group common/Func/CoreFunc
    ../../../common/Func/CoreFunc/: CoreChipFlash.c CoreChipFlash.h CoreChipTempSensor.c CoreChipTempSensor.h CoreDAC.c CoreDAC.h CoreIIC.c CoreIIC.h CoreRand.c CoreRand.h CoreRTC.c CoreRTC.h CoreSerialUart1DMA.c CoreSerialUart1DMA.h CoreSPI.c CoreSPI.h CoreTickDelay.c CoreTickDelay.h CoreTimerCapture.c CoreTimerCapture.h CoreWWDG.c CoreWWDG.h
  group common/Func/DeviceFunc
    ../../../common/Func/DeviceFunc/: DeviceAT24CXX.c DeviceAT24CXX.h DeviceBeep.c DeviceBeep.h DeviceDHT11.c DeviceDHT11.h DeviceDS18B20.c DeviceDS18B20.h DeviceExti.c DeviceExti.h DeviceKey.c DeviceKey.h DeviceLCD.c DeviceLCD.h DeviceLed.c DeviceLed.h DeviceLightSensor.c DeviceLightSensor.h DeviceMPU6050.c DeviceMPU6050.h DevicePWM_DAC.c DevicePWM_DAC.h DeviceRS485.c DeviceRS485.h DeviceSDIO.c DeviceSDIO.h DeviceSRAM.c DeviceSRAM.h DeviceTouchKey.c DeviceTouchKey.h DeviceW25QXX.c DeviceW25QXX.h
  group common/Func/SupportFunc
    ../../../common/Func/SupportFunc/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c SystemUtil.c SystemUtil.h
  group common/lib/inc
    ../../../common/lib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group common/lib/src
    ../../../common/lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group common/startup
    ../../../common/startup/: startup_stm32f40_41xxx.s
  group common/startup/linker
    ../../../common/startup/linker/: stm32f407xG.icf
  group userfile
    ../UserFile/: Main.c
