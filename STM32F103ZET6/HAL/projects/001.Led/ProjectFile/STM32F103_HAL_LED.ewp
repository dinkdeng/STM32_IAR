# IAR project STM32F103_HAL_LED.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\common\lib\HAL\inc; ..\..\..\common\chipSupport; ..\..\..\common\Func\CallBackFunc; ..\..\..\common\Func\CoreFunc; ..\..\..\common\Func\DeviceFunc; ..\..\..\common\Func\DinkFunc; ..\..\..\common\Func\MspFunc; ..\..\..\common\Func\SupportFunc; ..\UserFile
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103_HAL_LED.hex
  ILINK.IlinkOutputFile: STM32F103_HAL_LED.out
  ILINK.IlinkIcfFile: ..\..\..\common\startup\linker\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common/chipSupport
    ../../../common/chipSupport/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f103xe.h stm32f1xx.h
  group common/Func/CoreFunc
    ../../../common/Func/CoreFunc/: CoreTimerDelay.c CoreTimerDelay.h
  group common/Func/DeviceFunc
    ../../../common/Func/DeviceFunc/: DeviceLed.c DeviceLed.h
  group common/Func/MspFunc
    ../../../common/Func/MspFunc/: MspHAL.c
  group common/Func/SupportFunc
    ../../../common/Func/SupportFunc/: stm32f1xx_hal_conf.h stm32f1xx_it.c stm32f1xx_it.h system_stm32f1xx.c system_stm32f1xx.h
  group common/lib/HAL/inc
    ../../../common/lib/HAL/inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_usb.h
  group common/lib/HAL/src
    ../../../common/lib/HAL/src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group common/startup
    ../../../common/startup/: startup_stm32f103xe.s
  group common/startup/linker
    ../../../common/startup/linker/: stm32f103xe_flash.icf
  group user
    ../UserFile/: LedMain.c
