<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\001.Led\ProjectFile\STM32F103_HAL_LED.ewp</path>
    </project>
    <batchBuild />
</workspace>
