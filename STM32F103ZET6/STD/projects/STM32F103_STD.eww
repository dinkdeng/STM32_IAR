<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\002.KeyScan\ProjectFile\STM32F103_STD_KEYSCAN.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\001.Led\ProjectFile\STM32F103_STD_LED.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\003.SerialGeneral\ProjectFile\STM32F103_STD_SERIAL_GENERAL.ewp</path>
    </project>
    <batchBuild />
</workspace>
