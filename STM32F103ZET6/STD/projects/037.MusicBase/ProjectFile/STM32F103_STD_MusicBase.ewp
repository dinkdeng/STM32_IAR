# IAR project STM32F103_STD_MusicBase.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\common\startup; ..\..\..\common\lib\inc; ..\..\..\common\chipSupport; ..\..\..\common\Func\CoreFunc; ..\..\..\common\Func\DeviceFunc; ..\..\..\common\Func\DinkFunc; ..\..\..\common\Func\SupportFunc; ..\..\..\common\Func\Fatfs; ..\UserFunc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103_STD_MusicBase.hex
  ILINK.IlinkOutputFile: STM32F103_STD_MusicBase.out
  ILINK.IlinkIcfFile: ..\..\..\common\startup\linker\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common/chipSupport
    ../../../common/chipSupport/: arm_common_tables.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h stm32f10x.h system_stm32f10x.h
  group common/Func/CoreFunc
    ../../../common/Func/CoreFunc/: CoreADC.c CoreADC.h CoreCAN.c CoreCAN.h CoreDAC.c CoreDAC.h CoreIIC.c CoreIIC.h CoreITEMP.c CoreITEMP.h CoreIWDG.c CoreIWDG.h CoreRTC.c CoreRTC.h CoreSerialUart1Dma.c CoreSerialUart1Dma.h CoreSPI.c CoreSPI.h CoreSTM32Flash.c CoreSTM32Flash.h CoreTickDelay.c CoreTickDelay.h CoreTimer3Ch2PWM.c CoreTimer3Ch2PWM.h CoreWWDG.c CoreWWDG.h
  group common/Func/DeviceFunc
    ../../../common/Func/DeviceFunc/: DeviceAdxl345.c DeviceAdxl345.h DeviceAT24Cxx.c DeviceAT24Cxx.h DeviceAudioSwitch.c DeviceAudioSwitch.h DeviceBeep.c DeviceBeep.h DeviceDHT11.c DeviceDHT11.h DeviceDS18b20.c DeviceDS18b20.h DeviceExti.c DeviceExti.h DeviceFCPAD.c DeviceFCPAD.h DeviceIR.c DeviceIR.h DeviceKey.c DeviceKey.h DeviceLed.c DeviceLed.h DeviceNRF24L01.c DeviceNRF24L01.h DevicePluseCapture.c DevicePluseCapture.h DevicePWM_DAC.c DevicePWM_DAC.h DeviceRDA5820.c DeviceRDA5820.h DeviceSD.c DeviceSD.h DeviceSRAM.c DeviceSRAM.h DeviceUart2RS485.c DeviceUart2RS485.h DeviceVS10xx.c DeviceVS10xx.h DeviceW25qxx.c DeviceW25qxx.h
  group common/Func/DinkFunc
    ../../../common/Func/DinkFunc/: MemManagerLocal.c MemManagerLocal.h MemManagerSRAM.c MemManagerSRAM.h
  group common/Func/Fatfs
    ../../../common/Func/Fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group common/Func/SupportFunc
    ../../../common/Func/SupportFunc/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c SystemUtil.c SystemUtil.h
  group common/lib/inc
    ../../../common/lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group common/lib/src
    ../../../common/lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group common/startup
    ../../../common/startup/: startup_stm32f103xe.s
  group common/startup/linker
    ../../../common/startup/linker/: stm32f103xE.icf
  group UserFunc
    ../UserFunc/: main.c
